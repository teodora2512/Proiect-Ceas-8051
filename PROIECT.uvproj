# Keil uVision project PROIECT.uvproj, settings and files
target Proiect (MCS-51)
  device: P89C51RD2Hxx NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: PROIECT +hex
  c flags: Optimize=8 SizeSpeed=1
  group CeasDigital
    ./: ceasDigital.a51
